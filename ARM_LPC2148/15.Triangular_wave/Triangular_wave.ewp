# IAR project Triangular_wave.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Triangular_wave.hex
  ILINK.IlinkOutputFile: UART0.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\examples\NXP\LPC23xx\IAR-LPC-2378-SK\simple\Common\icf\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: Triangular_wave.c
