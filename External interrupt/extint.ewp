# IAR project extint.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2148 NXP LPC2148
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: extint.hex
  ILINK.IlinkOutputFile: extint.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\examples\NXP\LPC214x\IAR-LPC-214X\ADC\Configuration\LPC2148_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: extint.c
    C:/Program Files/IAR Systems/Embedded Workbench 6.4/arm/examples/NXP/LPC214x/IAR-LPC-214X/ExtInt/Source/: lpc2xxx_cstartup.s
